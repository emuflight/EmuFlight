# IAR project ch.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F303xC ST STM32F303xC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCIncludePath2: ..\; ..\..\..\..\os\common\ports\ARMCMx\devices\STM32F3xx; ..\..\..\..\os\ext\CMSIS\include; ..\..\..\..\os\ext\CMSIS\ST\STM32F3xx; ..\..\..\..\os\rt\ports\ARMCMx; ..\..\..\..\os\rt\ports\ARMCMx\compilers\IAR; ..\..\..\..\os\rt\include; ..\..\..\..\os\hal\osal\rt; ..\..\..\..\os\hal\include; ..\..\..\..\os\hal\boards\ST_STM32F3_DISCOVERY; ..\..\..\..\os\hal\ports\common\ARMCMx; ..\..\..\..\os\hal\ports\STM32\STM32F3xx; ..\..\..\..\os\hal\ports\STM32\LLD; ..\..\..\..\os\hal\ports\STM32\LLD\ADCv3; ..\..\..\..\os\hal\ports\STM32\LLD\CANv1; ..\..\..\..\os\hal\ports\STM32\LLD\DMAv1; ..\..\..\..\os\hal\ports\STM32\LLD\EXTIv1; ..\..\..\..\os\hal\ports\STM32\LLD\GPIOv2; ..\..\..\..\os\hal\ports\STM32\LLD\I2Cv2; ..\..\..\..\os\hal\ports\STM32\LLD\RTCv2; ..\..\..\..\os\hal\ports\STM32\LLD\SPIv2; ..\..\..\..\os\hal\ports\STM32\LLD\TIMv1; ..\..\..\..\os\hal\ports\STM32\LLD\USARTv2; ..\..\..\..\os\hal\ports\STM32\LLD\USBv1; ..\..\..\..\os\hal\ports\STM32\LLD\xWDGv1; ..\..\..\..\test\rt
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..; ..\..\..\..\os\common\ports\ARMCMx\devices\STM32F3xx; ..\..\..\..\os\rt\ports\ARMCMx
  OBJCOPY.OOCOutputFile: ch.srec
  ILINK.IlinkOutputFile: ch.out
  ILINK.IlinkIcfFile: ch.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCOptLevel: 3
  group (top)
    ../: chconf.h halconf.h main.c mcuconf.h
  group os/common/ports
    ../../../../os/common/ports/ARMCMx/devices/STM32F3xx/: cmparams.h
    ../../../../os/common/ports/ARMCMx/compilers/IAR/: cstartup.s vectors.s
  group os/ext/CMSIS
    ../../../../os/ext/CMSIS/include/: core_cm4.h core_cm4_simd.h core_cmFunc.h core_cmInstr.h
    ../../../../os/ext/CMSIS/ST/: stm32f3xx.h system_stm32f3xx.h
  group os/hal/board
    ../../../../os/hal/boards/ST_STM32F3_DISCOVERY/: board.c board.h
  group os/hal/include
    ../../../../os/hal/include/: adc.h can.h dac.h ext.h gpt.h hal.h hal_buffers.h hal_channels.h hal_files.h hal_ioblock.h hal_mmcsd.h hal_queues.h hal_streams.h i2c.h i2s.h icu.h mac.h mii.h mmc_spi.h pal.h pwm.h rtc.h sdc.h serial.h serial_usb.h spi.h st.h uart.h usb.h wdg.h
  group os/hal/lib/streams
    ../../../../os/hal/lib/streams/: chprintf.c chprintf.h memstreams.c memstreams.h
  group os/hal/port
    ../../../../os/hal/ports/STM32/LLD/ADCv1/: adc_lld.c adc_lld.h
    ../../../../os/hal/ports/STM32/LLD/CANv1/: can_lld.c can_lld.h
    ../../../../os/hal/ports/STM32/LLD/DACv1/: dac_lld.c dac_lld.h
    ../../../../os/hal/ports/STM32/LLD/EXTIv1/: ext_lld.c ext_lld.h
    ../../../../os/hal/ports/STM32/STM32F3xx/: ext_lld_isr.c ext_lld_isr.h hal_lld.c hal_lld.h stm32_isr.h stm32_rcc.h stm32_registry.h
    ../../../../os/hal/ports/STM32/LLD/TIMv1/: gpt_lld.c gpt_lld.h icu_lld.c icu_lld.h pwm_lld.c pwm_lld.h st_lld.c st_lld.h stm32_tim.h
    ../../../../os/hal/ports/STM32/LLD/I2Cv2/: i2c_lld.c i2c_lld.h
    ../../../../os/hal/ports/common/ARMCMx/: nvic.c nvic.h
    ../../../../os/hal/ports/STM32/LLD/GPIOv2/: pal_lld.c pal_lld.h
    ../../../../os/hal/ports/STM32/LLD/RTCv2/: rtc_lld.c rtc_lld.h
    ../../../../os/hal/ports/STM32/LLD/USARTv2/: serial_lld.c serial_lld.h uart_lld.c uart_lld.h
    ../../../../os/hal/ports/STM32/LLD/SPIv2/: spi_lld.c spi_lld.h
    ../../../../os/hal/ports/STM32/LLD/DMAv1/: stm32_dma.c stm32_dma.h
    ../../../../os/hal/ports/STM32/LLD/USBv1/: stm32_usb.h usb_lld.c usb_lld.h
    ../../../../os/hal/ports/STM32/LLD/xWDGv1/: wdg_lld.c wdg_lld.h
  group os/hal/src
    ../../../../os/hal/src/: adc.c can.c dac.c ext.c gpt.c hal.c hal_buffers.c hal_mmcsd.c hal_queues.c i2c.c i2s.c icu.c mac.c mmc_spi.c pal.c pwm.c rtc.c sdc.c serial.c serial_usb.c spi.c st.c uart.c usb.c wdg.c
  group os/rt/include
    ../../../../os/rt/include/: ch.h chbsem.h chcond.h chdebug.h chdynamic.h chevents.h chheap.h chmboxes.h chmemcore.h chmempools.h chmsg.h chmtx.h chqueues.h chregistry.h chschd.h chsem.h chstats.h chstreams.h chsys.h chthreads.h chtm.h chvt.h
  group os/rt/port
    ../../../../os/rt/ports/ARMCMx/: chcore.c chcore.h chcore_timer.h chcore_v7m.c chcore_v7m.h
    ../../../../os/rt/ports/ARMCMx/compilers/IAR/: chcoreasm_v7m.s chtypes.h
  group os/rt/src
    ../../../../os/rt/src/: chcond.c chdebug.c chdynamic.c chevents.c chheap.c chmboxes.c chmemcore.c chmempools.c chmsg.c chmtx.c chqueues.c chregistry.c chschd.c chsem.c chstats.c chsys.c chthreads.c chtm.c chvt.c
  group test
    ../../../../test/rt/: test.c test.h testbmk.c testbmk.h testdyn.c testdyn.h testevt.c testevt.h testheap.c testheap.h testmbox.c testmbox.h testmsg.c testmsg.h testmtx.c testmtx.h testpools.c testpools.h testqueues.c testqueues.h testsem.c testsem.h testsys.c testsys.h testthd.c testthd.h
